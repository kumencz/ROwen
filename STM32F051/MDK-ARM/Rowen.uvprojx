# Keil uVision project Rowen.uvprojx, settings and files
target STM32F051C4 (ARM-ADS)
  device: STM32F051C4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Rowen
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F051
  c include: ..\inc;..\STM32F0xx_StdPeriph_Driver\inc;.\RTE\Device\STM32F051C4;.\RTE\;..\CMSIS_Include
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Main code
    ../src/: main.c stm32f0xx_it.c
  group STM32F0xx_StdPeriph_Driver
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_adc.c stm32f0xx_comp.c stm32f0xx_dac.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.5.0
