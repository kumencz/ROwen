# Keil uVision project ROwen.uvproj, settings and files
target ROwen Configuration (ARM-ADS)
  device: STM32F051C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: ROwen Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F051x8
  c misc: --C99
  c include: ..\Inc; ..\Drivers\STM32F0xx_HAL_Driver\Inc; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F0xx\Include
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_uart_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_pwr.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c
  group Application/User
    ../Src/: i2c.c tim.c stm32f0xx_hal_msp.c main.c usart.c comp.c stm32f0xx_it.c gpio.c i2c.c tim.c stm32f0xx_hal_msp.c main.c usart.c comp.c stm32f0xx_it.c gpio.c i2c.c tim.c stm32f0xx_hal_msp.c main.c usart.c comp.c stm32f0xx_it.c gpio.c i2c.c tim.c stm32f0xx_hal_msp.c main.c usart.c comp.c stm32f0xx_it.c gpio.c i2c.c tim.c stm32f0xx_hal_msp.c main.c usart.c comp.c stm32f0xx_it.c gpio.c i2c.c tim.c stm32f0xx_hal_msp.c main.c usart.c comp.c stm32f0xx_it.c gpio.c i2c.c tim.c stm32f0xx_hal_msp.c main.c usart.c comp.c stm32f0xx_it.c gpio.c i2c.c tim.c stm32f0xx_hal_msp.c main.c usart.c comp.c stm32f0xx_it.c gpio.c i2c.c tim.c stm32f0xx_hal_msp.c main.c usart.c comp.c stm32f0xx_it.c gpio.c i2c.c tim.c stm32f0xx_hal_msp.c main.c usart.c comp.c stm32f0xx_it.c gpio.c i2c.c tim.c stm32f0xx_hal_msp.c main.c usart.c comp.c stm32f0xx_it.c gpio.c i2c.c tim.c stm32f0xx_hal_msp.c main.c usart.c comp.c stm32f0xx_it.c gpio.c i2c.c tim.c stm32f0xx_hal_msp.c main.c usart.c comp.c stm32f0xx_it.c gpio.c i2c.c tim.c stm32f0xx_hal_msp.c main.c usart.c comp.c stm32f0xx_it.c gpio.c i2c.c tim.c stm32f0xx_hal_msp.c main.c usart.c comp.c stm32f0xx_it.c gpio.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c system_stm32f0xx.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f051x8.s startup_stm32f051x8.s startup_stm32f051x8.s startup_stm32f051x8.s startup_stm32f051x8.s startup_stm32f051x8.s startup_stm32f051x8.s startup_stm32f051x8.s startup_stm32f051x8.s startup_stm32f051x8.s startup_stm32f051x8.s startup_stm32f051x8.s startup_stm32f051x8.s startup_stm32f051x8.s startup_stm32f051x8.s
