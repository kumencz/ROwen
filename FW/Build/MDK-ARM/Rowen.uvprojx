# Keil uVision project Rowen.uvprojx, settings and files
target STM32F051C4 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F051C4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Rowen +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F051
  c include: ..\CMSIS_Include;..\STM32F0xx_StdPeriph_Driver\inc;..\inc;..\System
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Main code
    ../src/: main.c stm32f0xx_it.c time.c comunication.c control.c hmi.c power.c init.c i2c.c uart.c
  group STM32F0xx_StdPeriph_Driver
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_adc.c stm32f0xx_comp.c stm32f0xx_dac.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c
  group System
    ../System/: system_stm32f0xx.c startup_stm32f051.s
